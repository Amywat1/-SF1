# Keil uVision project SF1-K.uvproj, settings and files
target SF1-K (MCS-51)
  device: SH79F328 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x7FFF) XRAM(0-0x500) CLOCK(24000000)
  output: SF1-K +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER;..\SYSTEM;..\HARDWARE
  group USER
    ./: STARTUP.A51 main.c common_sino_wealth.c
  group SYSTEM
    ../SYSTEM/: initialize.c delay.c interrupt.c sysmode.c uart.c
  group HARDWARE
    ../HARDWARE/: display.c load.c measure.c touchkey.c buzzer.c wifi.c
